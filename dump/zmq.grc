options:
  parameters:
    generate_options: qt_gui
    id: zmq
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cent_freq
  id: variable_qtgui_range
  parameters:
    start: 1110e6
    step: '50000000'
    stop: 1110e6
    value: 1110e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '625000'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: M1
    size: '2048'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: raw
    size: '2048'
    srate: samp_rate
    type: complex
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: cent_freq
    fftsize: '8192'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: 25e8
    clock_source0: internal
    rx_agc0: Enabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:6666
    timeout: '100'
    type: float
  states: {}
- name: zeromq_sub_source_0_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:7777
    timeout: '100'
    type: complex
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [zeromq_sub_source_0, '0', qtgui_const_sink_x_0, '0']
- [zeromq_sub_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [zeromq_sub_source_0_0, '0', qtgui_time_sink_x_0, '0']
- [zeromq_sub_source_0_0_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
